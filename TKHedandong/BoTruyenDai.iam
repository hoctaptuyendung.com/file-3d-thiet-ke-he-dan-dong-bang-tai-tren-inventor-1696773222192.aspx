# Autodesk Inventor assembly: BoTruyenDai
## iProperties
Created: 2011-05
Part Number: BoTruyenDai
Document SubType Name: Assembly
Designer: 904Chiaki
Author: 904Chiaki
