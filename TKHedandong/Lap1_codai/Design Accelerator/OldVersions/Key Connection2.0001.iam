# Autodesk Inventor assembly: Key Connection
## iProperties
Created: 2011-05
Part Number: Key Connection
Document SubType Name: Assembly
Designer: 904Chiaki
ClientObjectVersion: 1
Author: 904Chiaki
