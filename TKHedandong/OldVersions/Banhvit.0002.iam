# Autodesk Inventor assembly: Banhvit
## iProperties
Created: 2011-06
Part Number: Banhvit
Document SubType Name: Assembly
Designer: 904Chiaki
Author: 904Chiaki
