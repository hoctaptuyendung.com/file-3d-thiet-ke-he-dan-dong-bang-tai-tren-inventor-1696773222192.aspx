# Autodesk Inventor assembly: Lap1_codai
## iProperties
Created: 2011-05
Part Number: Lap1_codai
Document SubType Name: Assembly
Designer: 904Chiaki
Author: 904Chiaki
