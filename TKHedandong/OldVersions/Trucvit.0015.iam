# Autodesk Inventor assembly: Trucvit
## iProperties
Created: 2011-05
Part Number: Trucvit
Document SubType Name: Assembly
Designer: 904Chiaki
Author: 904Chiaki
